# Keil uVision project RTCmoduleCore.uvprojx, settings and files
target WordClock (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WordClock
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group main
    ./: main.cpp delay.cpp delay.h init.cpp init.h
  group comm
    ./: i2c.cpp i2c.h spi.cpp spi.h uart.cpp uart.h
  group clock
    ./: ds1307.h ds1307.cpp max7219.cpp max7219.h wordclock.cpp wordclock.h
software components: CMSIS:CORE 5.0.0, Device:Startup 2.2.3
